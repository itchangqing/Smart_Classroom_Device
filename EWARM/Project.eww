<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Smart_Classroom_Device.ewp</path>
  </project>
  <batchBuild />
</workspace>
